# Keil uVision project Project.uvprojx, settings and files
target Target 1 (6210000::V6.21::ARMCLANG)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Project +hex
  c flags: Optim=7 OneElfS=1 uC99=1 v6Lang=4 v6LangP=1 wLevel=1
  c define: USE_STDPERIPH_DRIVER
  c include: .\Start;.\User;.\Library;.\SYSTEM\delay;.\SYSTEM\sys;.\SYSTEM\usart;.\HARDWARE;.\SYSTEM\timer;.\HARDWARE\MAX30102;.\HARDWARE\OLED;.\HARDWARE\DS18B20;.\HARDWARE\LED;.\HARDWARE\ADXL345;.\HARDWARE\USB;.\HARDWARE\ALARM;.\HARDWARE\FALL;.\HARDWARE\FLASH
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Start
    ./Start/: startup_stm32f10x_md.s core_cm3.c core_cm3.h stm32f10x.h system_stm32f10x.c system_stm32f10x.h
  group Library
    ./Library/: misc.c misc.h stm32f10x_adc.c stm32f10x_adc.h stm32f10x_bkp.c stm32f10x_bkp.h stm32f10x_can.c stm32f10x_can.h stm32f10x_cec.c stm32f10x_cec.h stm32f10x_crc.c stm32f10x_crc.h stm32f10x_dac.c stm32f10x_dac.h stm32f10x_dbgmcu.c stm32f10x_dbgmcu.h stm32f10x_dma.c stm32f10x_dma.h stm32f10x_exti.c stm32f10x_exti.h stm32f10x_flash.c stm32f10x_flash.h stm32f10x_fsmc.c stm32f10x_fsmc.h stm32f10x_gpio.c stm32f10x_gpio.h stm32f10x_i2c.c stm32f10x_i2c.h stm32f10x_iwdg.c stm32f10x_iwdg.h stm32f10x_pwr.c stm32f10x_pwr.h stm32f10x_rcc.c stm32f10x_rcc.h stm32f10x_rtc.c stm32f10x_rtc.h stm32f10x_sdio.c stm32f10x_sdio.h stm32f10x_spi.c stm32f10x_spi.h stm32f10x_tim.c stm32f10x_tim.h stm32f10x_usart.c stm32f10x_usart.h stm32f10x_wwdg.c stm32f10x_wwdg.h
  group User
    ./User/: main.c stm32f10x_conf.h stm32f10x_it.c stm32f10x_it.h
  group HARDWARE
    ./HARDWARE/OLED/: oled.c
    ./HARDWARE/DS18B20/: ds18b20.c
    ./HARDWARE/LED/: led.c
    ./HARDWARE/ADXL345/: adxl345.c
    ./HARDWARE/MAX30102/: algorithm.c max30102.c myiic.c
    ./HARDWARE/USB/: usb_cdc.c
  group SYSTEM
    ./SYSTEM/delay/: delay.c
    ./SYSTEM/sys/: sys.c bkp_state.c
    ./SYSTEM/usart/: usart.c
    ./SYSTEM/timer/: timer.c
  group ALARM
    ./HARDWARE/ALARM/: alarm.c
  group FALL
    ./HARDWARE/FALL/: fall.c
  group FLASH
    ./HARDWARE/FLASH/: flash_hist.c
